# Keil uVision project WIRELESS_PLC.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: WIRELESS_PLC +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Include;.\FreeModBus\Inc
  group USER
    ./Source/: main.c Control.c report.c
  group GUI
    ./Source/: Menu.c
  group SYSTEM
    ./Source/: pFunc.c systemTimer.c
  group HADWARE
    ./Source/: usart.c timer.c wifi.c
  group STCLIB
    ./STCLIB/: Front.LIB Gpio.LIB Iape2prom.LIB Key.LIB Lcd19264.LIB
  group ASM
    ./: STARTUP.A51
  group README
    ./Readme/: readme.txt
